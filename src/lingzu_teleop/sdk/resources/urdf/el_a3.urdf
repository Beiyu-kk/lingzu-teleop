Commit message: 修改了夹爪的范围

File: src/lingzu_teleop/sdk/resources/urdf/el_a3.urdf (robot description, URDF)
Before this commit: robot EL-A3, 10 links, 9 joints
Joints:
- joint L7_joint: limit lower=-1.5708 upper=1.5708 effort=6.0 velocity=50 -> lower=0.0 upper=1.893682 effort=6.0 velocity=50
